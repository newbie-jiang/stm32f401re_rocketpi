# Keil uVision project 05_rocketpi_smart_home.uvprojx, settings and files
target 05_rocketpi_smart_home (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 05_rocketpi_smart_home +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp/esp8266_at;../bsp/aht30;../bsp/motor_l9110;../bsp/passive_buzzer;../bsp/st7789;..\app;..\component\cjson
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group bsp/esp8266_at
    ../bsp/esp8266_at/: driver_esp8266_at.c driver_esp8266_at_interface.c driver_esp8266_at_test.c
  group bsp/aht30
    ../bsp/aht30/: driver_aht30.c driver_aht30_test.c driver_aht30_config.h
  group bsp/motor_l9110
    ../bsp/motor_l9110/: driver_motor_l9110.c driver_motor_l9110_test.c
  group bsp/passive_buzzer
    ../bsp/passive_buzzer/: driver_buzzer_test.c
  group bsp/st7789
    ../bsp/st7789/: st7789.c font16x24_ascii.h
  group app
    ../app/: app.c
  group cjson
    ../component/cjson/: cJSON.c
software components: CMSIS:CORE 4.3.0
