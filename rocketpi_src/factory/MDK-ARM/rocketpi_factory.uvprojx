# Keil uVision project rocketpi_factory.uvprojx, settings and files
target rocketpi_factory (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: rocketpi_factory +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../lvgl;../lvgl/porting;../lvgl/demos;../lvgl/examples;../bsp/st7789;../bsp/adc_joystick;../../factory;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../component/MultiButton;../unit_test;../app;../bsp/aht30;../bsp/at24xx;../bsp/soft_i2c;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../component/microrl/src;../component/EasyLogger/easylogger/inc;../bsp/passive_buzzer;../bsp/irda
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group lvgl/demos
    ../lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_cogwheel_alpha256.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_benchmark_montserrat_12_compr_az.c.c lv_font_benchmark_montserrat_16_compr_az.c.c lv_font_benchmark_montserrat_28_compr_az.c.c
    ../lvgl/demos/flex_layout/: lv_demo_flex_layout_ctrl_pad.c lv_demo_flex_layout_flex_loader.c lv_demo_flex_layout_main.c lv_demo_flex_layout_view.c lv_demo_flex_layout_view_child_node.c lv_demo_flex_layout_view_ctrl_pad.c
    ../lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../lvgl/demos/multilang/assets/avatars/: img_multilang_avatar_1.c img_multilang_avatar_2.c img_multilang_avatar_3.c img_multilang_avatar_4.c img_multilang_avatar_5.c img_multilang_avatar_6.c img_multilang_avatar_7.c img_multilang_avatar_8.c img_multilang_avatar_9.c img_multilang_avatar_10.c img_multilang_avatar_11.c img_multilang_avatar_12.c img_multilang_avatar_13.c img_multilang_avatar_14.c img_multilang_avatar_15.c img_multilang_avatar_16.c img_multilang_avatar_17.c img_multilang_avatar_18.c img_multilang_avatar_19.c img_multilang_avatar_22.c img_multilang_avatar_25.c
    ../lvgl/demos/multilang/assets/emojis/: img_emoji_artist_palette.c img_emoji_books.c img_emoji_camera_with_flash.c img_emoji_cat_face.c img_emoji_deciduous_tree.c img_emoji_dog_face.c img_emoji_earth_globe_europe_africa.c img_emoji_flexed_biceps.c img_emoji_movie_camera.c img_emoji_red_heart.c img_emoji_rocket.c img_emoji_soccer_ball.c
    ../lvgl/demos/multilang/assets/fonts/: font_multilang_large.c font_multilang_small.c
    ../lvgl/demos/multilang/assets/: img_multilang_like.c
    ../lvgl/demos/multilang/: lv_demo_multilang.c
    ../lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../lvgl/demos/render/assets/: img_render_arc_bg.c img_render_lvgl_logo_argb8888.c img_render_lvgl_logo_i1.c img_render_lvgl_logo_l8.c img_render_lvgl_logo_rgb565.c img_render_lvgl_logo_rgb888.c img_render_lvgl_logo_xrgb8888.c
    ../lvgl/demos/render/: lv_demo_render.c
    ../lvgl/demos/scroll/: lv_demo_scroll.c
    ../lvgl/demos/stress/: lv_demo_stress.c
    ../lvgl/demos/transform/assets/: img_transform_avatar_15.c
    ../lvgl/demos/transform/: lv_demo_transform.c
    ../lvgl/demos/vector_graphic/assets/: img_demo_vector_avatar.c
    ../lvgl/demos/vector_graphic/: lv_demo_vector_graphic.c
    ../lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    ../lvgl/demos/widgets/: lv_demo_widgets.c
    ../lvgl/demos/: lv_demos.c
  group lvgl/example
    ../lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_timeline_1.c
    ../lvgl/examples/assets/emoji/: img_emoji_F617.c
    ../lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c img_caret_down.c img_cogwheel_argb.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c
    ../lvgl/examples/event/: lv_example_event_1.c lv_example_event_2.c lv_example_event_3.c lv_example_event_4.c
    ../lvgl/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c lv_example_get_started_4.c
    ../lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c
    ../lvgl/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_5.c lv_example_grid_6.c
    ../lvgl/examples/libs/barcode/: lv_example_barcode_1.c
    ../lvgl/examples/libs/bmp/: lv_example_bmp_1.c
    ../lvgl/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
    ../lvgl/examples/libs/freetype/: lv_example_freetype_1.c
    ../lvgl/examples/libs/gif/: img_bulb_gif.c lv_example_gif_1.c
    ../lvgl/examples/libs/libjpeg_turbo/: lv_example_libjpeg_turbo_1.c
    ../lvgl/examples/libs/libpng/: img_png_demo.c lv_example_libpng_1.c
    ../lvgl/examples/libs/lodepng/: img_wink_png.c lv_example_lodepng_1.c
    ../lvgl/examples/libs/qrcode/: lv_example_qrcode_1.c
    ../lvgl/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
    ../lvgl/examples/libs/tiny_ttf/: lv_example_tiny_ttf_1.c lv_example_tiny_ttf_2.c lv_example_tiny_ttf_3.c ubuntu_font.c
    ../lvgl/examples/libs/tjpgd/: lv_example_tjpgd_1.c
    ../lvgl/examples/others/file_explorer/: lv_example_file_explorer_1.c lv_example_file_explorer_2.c lv_example_file_explorer_3.c
    ../lvgl/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
    ../lvgl/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_2.c lv_example_gridnav_3.c lv_example_gridnav_4.c lv_example_gridnav_5.c
    ../lvgl/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
    ../lvgl/examples/others/imgfont/: lv_example_imgfont_1.c
    ../lvgl/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
    ../lvgl/examples/others/observer/: lv_example_observer_1.c lv_example_observer_2.c lv_example_observer_3.c lv_example_observer_4.c lv_example_observer_5.c lv_example_observer_6.c
    ../lvgl/examples/others/snapshot/: lv_example_snapshot_1.c
    ../lvgl/examples/scroll/: lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_3.c lv_example_scroll_4.c lv_example_scroll_5.c lv_example_scroll_6.c
    ../lvgl/examples/styles/: lv_example_style_1.c lv_example_style_2.c lv_example_style_3.c lv_example_style_4.c lv_example_style_5.c lv_example_style_6.c lv_example_style_7.c lv_example_style_8.c lv_example_style_9.c lv_example_style_10.c lv_example_style_11.c lv_example_style_12.c lv_example_style_13.c lv_example_style_14.c lv_example_style_15.c lv_example_style_16.c lv_example_style_17.c lv_example_style_18.c
    ../lvgl/examples/widgets/animimg/: lv_example_animimg_1.c
    ../lvgl/examples/widgets/arc/: lv_example_arc_1.c lv_example_arc_2.c
    ../lvgl/examples/widgets/bar/: lv_example_bar_1.c lv_example_bar_2.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_5.c lv_example_bar_6.c lv_example_bar_7.c
    ../lvgl/examples/widgets/button/: lv_example_button_1.c lv_example_button_2.c lv_example_button_3.c
    ../lvgl/examples/widgets/buttonmatrix/: lv_example_buttonmatrix_1.c lv_example_buttonmatrix_2.c lv_example_buttonmatrix_3.c
    ../lvgl/examples/widgets/calendar/: lv_example_calendar_1.c lv_example_calendar_2.c
    ../lvgl/examples/widgets/canvas/: lv_example_canvas_1.c lv_example_canvas_2.c lv_example_canvas_3.c lv_example_canvas_4.c lv_example_canvas_5.c lv_example_canvas_6.c lv_example_canvas_7.c lv_example_canvas_8.c
    ../lvgl/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_4.c lv_example_chart_5.c lv_example_chart_6.c lv_example_chart_7.c lv_example_chart_8.c
    ../lvgl/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
    ../lvgl/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
    ../lvgl/examples/widgets/image/: lv_example_image_1.c lv_example_image_2.c lv_example_image_3.c lv_example_image_4.c
    ../lvgl/examples/widgets/imagebutton/: lv_example_imagebutton_1.c
    ../lvgl/examples/widgets/keyboard/: lv_example_keyboard_1.c lv_example_keyboard_2.c
    ../lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c lv_example_label_5.c
    ../lvgl/examples/widgets/led/: lv_example_led_1.c
    ../lvgl/examples/widgets/line/: lv_example_line_1.c
    ../lvgl/examples/widgets/list/: lv_example_list_1.c lv_example_list_2.c
    ../lvgl/examples/widgets/lottie/: lv_example_lottie_1.c lv_example_lottie_2.c lv_example_lottie_approve.c
    ../lvgl/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_4.c lv_example_menu_5.c
    ../lvgl/examples/widgets/msgbox/: lv_example_msgbox_1.c lv_example_msgbox_2.c
    ../lvgl/examples/widgets/obj/: lv_example_obj_1.c lv_example_obj_2.c
    ../lvgl/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_2.c lv_example_roller_3.c
    ../lvgl/examples/widgets/scale/: lv_example_scale_1.c lv_example_scale_2.c lv_example_scale_3.c lv_example_scale_4.c lv_example_scale_5.c lv_example_scale_6.c lv_example_scale_7.c
    ../lvgl/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c lv_example_slider_4.c
    ../lvgl/examples/widgets/span/: lv_example_span_1.c
    ../lvgl/examples/widgets/spinbox/: lv_example_spinbox_1.c
    ../lvgl/examples/widgets/spinner/: lv_example_spinner_1.c
    ../lvgl/examples/widgets/switch/: lv_example_switch_1.c
    ../lvgl/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
    ../lvgl/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
    ../lvgl/examples/widgets/textarea/: lv_example_textarea_1.c lv_example_textarea_2.c lv_example_textarea_3.c
    ../lvgl/examples/widgets/tileview/: lv_example_tileview_1.c
    ../lvgl/examples/widgets/win/: lv_example_win_1.c
  group lvgl/porting
    ../lvgl/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl/config
    ../lvgl/: lv_conf.h
    ../lvgl/src/: lv_init.c
  group lvgl/src/core
    ../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group lvgl/src/display
    ../lvgl/src/display/: lv_display.c
  group lvgl/src/draw
    ../lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group lvgl/src/driver
    ../lvgl/src/drivers/evdev/: lv_evdev.c
    ../lvgl/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c
    ../lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../lvgl/src/drivers/qnx/: lv_qnx.c
    ../lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c
    ../lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group lvgl/src/font
    ../lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/indev
    ../lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group lvgl/src/layouts
    ../lvgl/src/layouts/flex/: lv_flex.c
    ../lvgl/src/layouts/grid/: lv_grid.c
    ../lvgl/src/layouts/: lv_layout.c
  group lvgl/src/libs
    ../lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../lvgl/src/libs/bmp/: lv_bmp.c
    ../lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../lvgl/src/libs/libpng/: lv_libpng.c
    ../lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../lvgl/src/libs/lz4/: lz4.c
    ../lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl/src/libs/rle/: lv_rle.c
    ../lvgl/src/libs/rlottie/: lv_rlottie.c
    ../lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group lvgl/src/misc
    ../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
  group lvgl/src/osal
    ../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group lvgl/src/others
    ../lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl/src/others/gridnav/: lv_gridnav.c
    ../lvgl/src/others/ime/: lv_ime_pinyin.c
    ../lvgl/src/others/imgfont/: lv_imgfont.c
    ../lvgl/src/others/monkey/: lv_monkey.c
    ../lvgl/src/others/observer/: lv_observer.c
    ../lvgl/src/others/snapshot/: lv_snapshot.c
    ../lvgl/src/others/sysmon/: lv_sysmon.c
    ../lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
  group lvgl/src/stdlib
    ../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../lvgl/src/stdlib/: lv_mem.c
  group lvgl/src/themes
    ../lvgl/src/themes/default/: lv_theme_default.c
    ../lvgl/src/themes/mono/: lv_theme_mono.c
    ../lvgl/src/themes/simple/: lv_theme_simple.c
    ../lvgl/src/themes/: lv_theme.c
  group lvgl/src/tick
    ../lvgl/src/tick/: lv_tick.c
  group lvgl/src/widgets
    ../lvgl/src/widgets/animimage/: lv_animimage.c
    ../lvgl/src/widgets/arc/: lv_arc.c
    ../lvgl/src/widgets/bar/: lv_bar.c
    ../lvgl/src/widgets/button/: lv_button.c
    ../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/widgets/canvas/: lv_canvas.c
    ../lvgl/src/widgets/chart/: lv_chart.c
    ../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../lvgl/src/widgets/image/: lv_image.c
    ../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/widgets/label/: lv_label.c
    ../lvgl/src/widgets/led/: lv_led.c
    ../lvgl/src/widgets/line/: lv_line.c
    ../lvgl/src/widgets/list/: lv_list.c
    ../lvgl/src/widgets/lottie/: lv_lottie.c
    ../lvgl/src/widgets/menu/: lv_menu.c
    ../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgl/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ../lvgl/src/widgets/roller/: lv_roller.c
    ../lvgl/src/widgets/scale/: lv_scale.c
    ../lvgl/src/widgets/slider/: lv_slider.c
    ../lvgl/src/widgets/span/: lv_span.c
    ../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/widgets/spinner/: lv_spinner.c
    ../lvgl/src/widgets/switch/: lv_switch.c
    ../lvgl/src/widgets/table/: lv_table.c
    ../lvgl/src/widgets/tabview/: lv_tabview.c
    ../lvgl/src/widgets/tileview/: lv_tileview.c
    ../lvgl/src/widgets/win/: lv_win.c
    ../lvgl/src/widgets/textarea/: lv_textarea.c
  group lvgl/pic
    ../lvgl/pic/: rocket_cloud_80x80_01.c rocket_cloud_80x80_02.c rocket_cloud_80x80_03.c rocket_cloud_80x80_04.c rocket_cloud_80x80_05.c rocket_cloud_80x80_06.c rocket_cloud_80x80_07.c rocket_cloud_80x80_08.c rocket_cloud_80x80_09.c rocket_cloud_80x80_10.c humidity_30x30.c temp_30x30.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group unit
    ../unit_test/: unit_test_shell.c unit_test_led.c unit_test_button.c unit_test_buzzer.c unit_test_aht30.c unit_test_at24cxx.c unit_test_card.c unit_test_irda.c unit_test_lvgl.c unit_test_usb_cdc.c unit_test_admin.c unit_test_extern_io_.c
  group app
    ../app/: app.c
  group bsp/debug
    ../bsp/debug/: debug_driver.c
  group bsp/aht30
    ../bsp/aht30/: driver_aht30.c
  group bsp/at24cxx
    ../bsp/at24xx/: driver_at24cxx.c driver_at24cxx_basic.c driver_at24cxx_interface.c driver_at24cxx_read_test.c
  group bsp/irda
    ../bsp/irda/: driver_ir_remote.c driver_ir_remote_basic.c driver_ir_remote_interface.c driver_ir_remote_receive_test.c
  group bsp/soft_i2c
    ../bsp/soft_i2c/: soft_i2c.c
  group bsp/st7789
    ../bsp/st7789/: st7789.c
  group bsp/adc_joystick
    ../bsp/adc_joystick/: driver_adc_joystick_lcd.c driver_adc_joystick_test.c
  group bsp/passive_buzzer
    ../bsp/passive_buzzer/: driver_buzzer_test.c
  group component/multibutton
    ../component/MultiButton/: multi_button.c
  group component/microrl
    ../component/microrl/src/: microrl.c
  group component/easylogger
    ../component/EasyLogger/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../component/EasyLogger/easylogger/port/: elog_port.c
software components: CMSIS:CORE 4.3.0
